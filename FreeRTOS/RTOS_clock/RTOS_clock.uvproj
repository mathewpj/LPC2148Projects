# Keil uVision project RTOS_clock.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOS_clock +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KIEL_THUMB_INTERWORK
  c include: C:\FreeRTOSv10.0.0\FreeRTOSv10.0.0\FreeRTOS\Source\include;C:\FreeRTOSv10.0.0\FreeRTOSv10.0.0\FreeRTOS\Source\portable\MemMang;.
  asm include: C:\FreeRTOSv10.0.0\FreeRTOSv10.0.0\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s LCDRoutines.c main.c
    C:/FreeRTOSv10.0.0/FreeRTOSv10.0.0/FreeRTOS/Source/: tasks.c list.c
    C:/FreeRTOSv10.0.0/FreeRTOSv10.0.0/FreeRTOS/Source/portable/MemMang/: heap_1.c
    C:/FreeRTOSv10.0.0/FreeRTOSv10.0.0/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
